# Keil uVision project mbed_blinky.uvproj, settings and files
target mbed NXP LPC1114 (ARM-ADS)
  device: LPC1114/102 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: mbed_blinky
  AfterMake: $K\ARM\BIN\ELFDWT.EXE "!L"
  AfterMake: fromelf --bin -o mbed_blinky_LPC1114.bin build\mbed_blinky.axf
  c flags: Optim=1
  c define: TARGET_LPC1114,  TARGET_M0,  TARGET_CORTEX_M,  TARGET_NXP,  TARGET_LPC11XX_11CXX,  TARGET_LPC11XX,  TOOLCHAIN_ARM_MICRO,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1416586735.84,  __MBED__=1,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;mbed;mbed/TARGET_LPC1114;mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO;mbed/TARGET_LPC1114/TARGET_NXP;mbed/TARGET_LPC1114/TARGET_NXP/TARGET_LPC11XX_11CXX;mbed/TARGET_LPC1114/TARGET_NXP/TARGET_LPC11XX_11CXX/TARGET_LPC11XX;.\devices
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  scatter file: mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/LPC1114.sct
  link misc: mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/startup_LPC11xx.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/retarget.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/board.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/cmsis_nvic.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/system_LPC11xx.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/sys.o
            
              mbed/TARGET_LPC1114/TOOLCHAIN_ARM_MICRO/mbed.ar
  group src
    ./: main.cpp
    ./: DS3231.cpp DS2482.cpp TextLCD.cpp LogicEngine.cpp Menu.cpp InterruptManager.cpp Watchdog.cpp IAP.cpp
  group headers
    ./: DS3231.h DS2482.h TextLCD.h LogicEngine.h Menu.h InterruptManager.h PinDetect.h Watchdog.h IAP.h configurationEnum.h
